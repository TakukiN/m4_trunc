# IAR project m4_trunc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __DEBUG; CPU_MCIMX7D_M4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\platform\CMSIS\Include; ..\..\platform\drivers\inc; ..\..\platform\devices\MCIMX7D\include; ..\..\platform\devices; ..\..\platform\devices\MCIMX7D\startup; ..\..\platform\utilities\inc; ..\..\middleware\rtos\FreeRTOS\Source\include; ..\..\middleware\multicore\open-amp\porting\env\freertos; ..\..\middleware\multicore\open-amp\porting\imx7d_m4; ..; ..\..\middleware\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\middleware\multicore\open-amp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: __DEBUG
  AARM.AUserIncludes: ../../../../../rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../..; ..
  OBJCOPY.OOCOutputFile: m4_trunc.bin
  ILINK.IlinkOutputFile: m4_trunc.out
  ILINK.IlinkIcfFile: C:\nxp\M4_trunc\platform\devices\MCIMX7D\linker\iar\MCIMX7D_M4_tcm.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __NDEBUG; CPU_MCIMX7D_M4
  ICCARM.CCIncludePath2: ../../../../../rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MCIMX7D/include; ../../../../../platform/devices/MCIMX7D/startup; ../../../../../platform/drivers/inc; ../../../../../rtos/FreeRTOS/Source/include; ../../../../../platform/utilities/inc; ../../..; ..
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 1
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MCIMX7D/linker/iar/MCIMX7D_M4_tcm.icf
  group middleware/multicore/open-amp/common/hil
    ../../middleware/multicore/open-amp/common/hil/: hil.c hil.h
  group middleware/multicore/open-amp/common/llist
    ../../middleware/multicore/open-amp/common/llist/: llist.c llist.h
  group middleware/multicore/open-amp/common/shm
    ../../middleware/multicore/open-amp/common/shm/: sh_mem.c sh_mem.h
  group middleware/multicore/open-amp/docs
    ../../middleware/multicore/open-amp/docs/: openamp_gs.pdf openamp_perf_meas_gd.pdf openamp_ref.pdf
  group middleware/multicore/open-amp/porting/config
    ../../middleware/multicore/open-amp/porting/config/: config.c config.h
  group middleware/multicore/open-amp/porting/env
    ../../middleware/multicore/open-amp/porting/env/: env.h
  group middleware/multicore/open-amp/porting/env/rtos
    ../../middleware/multicore/open-amp/porting/env/freertos/: rpmsg_porting.c rpmsg_porting.h
  group middleware/multicore/open-amp/porting/imx7d_m4
    ../../middleware/multicore/open-amp/porting/imx7d_m4/: platform.c platform.h platform_info.c rpmsg_platform_porting.h
  group middleware/multicore/open-amp/rpmsg
    ../../middleware/multicore/open-amp/rpmsg/: remote_device.c rpmsg.c rpmsg.h rpmsg_core.c rpmsg_core.h rpmsg_ext.c rpmsg_ext.h rpmsg_rtos.c rpmsg_rtos.h
  group middleware/multicore/open-amp/virtio
    ../../middleware/multicore/open-amp/virtio/: virtio.c virtio.h virtio_ring.h virtqueue.c virtqueue.h
  group middleware/rtos
    ../../middleware/rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group middleware/rtos/include
    ../../middleware/rtos/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h
  group middleware/rtos/portable/IAR/ARM_CM4F
    ../../middleware/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group middleware/rtos/portable/MemMang
    ../../middleware/rtos/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group platform/devices
    ../../platform/devices/: device_imx.h
  group platform/devices/MCIMX7D/include
    ../../platform/devices/MCIMX7D/include/: MCIMX7D_M4.h
  group platform/devices/MCIMX7D/startup
    ../../platform/devices/MCIMX7D/startup/: system_MCIMX7D_M4.c system_MCIMX7D_M4.h
  group platform/devices/MCIMX7D/startup/iar
    ../../platform/devices/MCIMX7D/startup/iar/: startup_MCIMX7D_M4.s
  group platform/driver/inc
    ../../platform/drivers/inc/: adc_imx7d.h ccm_analog_imx7d.h ccm_imx7d.h ecspi.h flexcan.h gpio_imx.h gpt.h i2c_imx.h lmem.h mu_imx.h rdc.h rdc_defs_imx7d.h rdc_semaphore.h sema4.h uart_imx.h wdog_imx.h
  group platform/driver/src
    ../../platform/drivers/src/: adc_imx7d.c ccm_analog_imx7d.c ccm_imx7d.c ecspi.c flexcan.c gpio_imx.c gpt.c i2c_imx.c lmem.c mu_imx.c rdc.c rdc_semaphore.c sema4.c uart_imx.c wdog_imx.c
  group platform/utilities/inc
    ../../platform/utilities/inc/: debug_console_imx.h
  group platform/utilities/src
    ../../platform/utilities/src/: debug_console_imx.c print_scan.c print_scan.h
  group system
    ../: board.c board.h clock_freq.c clock_freq.h FreeRTOSConfig.h hardware_init.c main.c pin_mux.c pin_mux.h
