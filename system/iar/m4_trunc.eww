<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>m4_trunc</project><configuration>Release</configuration></member><member><project>m4_trunc</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>m4_trunc</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>m4_trunc</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/m4_trunc.ewp</path></project></workspace>
